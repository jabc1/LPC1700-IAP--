# Keil uVision project LPC1700.uvproj, settings and files
target LPC1700 (ARM-ADS)
  device: LPC1765 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: IapCode +hex
  c flags: Optim=1 OneElfS=1
  c include: ..\;..\Source
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Cmsis
    ./: startup_LPC17xx.s
    ../Cmsis/Core/: core_cm3.c core_cm3.h
    ../Cmsis/System/: system_LPC17xx.c system_LPC17xx.h
  group LowDrive
    ../LowDrive/ADC/: ADC.c ADC.h
    ../LowDrive/DAC/: DAC.c DAC.h
    ../LowDrive/Gpio/: Gpio.c Gpio.h
    ../LowDrive/I2C/: I2C.c I2C.h
    ../LowDrive/RIT/: RIT.c RIT.h
    ../LowDrive/RTC/: RTC.c RTC.h
    ../LowDrive/SSP/: SSP.c SSP.h
    ../LowDrive/Wdt/: Wdt.c Wdt.h
    ../LowDrive/Uart/: Uart.c Uart.h
    ../LowDrive/SysTick/: SysTick.c SysTick.h
    ../LowDrive/Timer32/: Timer32.c Timer32.h
  group UppDrive
    ../UppDrive/Key/: Key.c Key.h
    ../UppDrive/ST7920/: ST7920.c ST7920.h
    ../UppDrive/W25Q80BV/: W25Q80BV.c W25Q80BV.h
    ../UppDrive/AT24C02/: AT24C02.c AT24C02.h
    ../UppDrive/SDCard/: SDCard.c SDCard.h
  group MidLayer
    ../MidLayer/St8x16/: St8x16.c St8x16.h
    ../MidLayer/TPC/: TPC.c TPC.h
    ../MidLayer/CMath/: CMath.c CMath.h
    ../MidLayer/FatFs/: diskio.c diskio.h ff.c ff.h ffconf.h integer.h
    ../MidLayer/IAP/: IAP.c IAP.h
  group AppCode
    ../AppCode/App/: App.c App.h
    ../AppCode/Task/: Task.c Task.h
    ../AppCode/HostCom/: HostCom.c HostCom.h
  group UserCode
    ../UserCode/It/: It.c It.h
    ../UserCode/Source/: config.h main.c
  group Doc
    ../Doc/: read me.txt
